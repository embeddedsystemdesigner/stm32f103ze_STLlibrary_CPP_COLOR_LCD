# Keil uVision project main.uvproj, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: main
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --exceptions
  c include: .\STM32F10x_FWLib\inc;.\emwin;C:\Keil_v5\ARM\Segger\emWin\Include;E:\stm32f103ze_STLlibrary_CPP_COLOR_LCD
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ./: startup_stm32f10x_hd.s system_stm32f10x.c
  group Source
    ./: usart.c main.cpp Retarget.c
  group CMSIS
    ./STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_fsmc.c
  group EMWIN
    ./emwin/: GUI_X.c GUI_X_Touch_Analog.c GUI_X_Touch_StoreState.c GUIConf.c LCDConf.c tftlcd.c touch.c
    C:/Keil_v5/ARM/Segger/emWin/Lib/: GUI_CM3.lib
